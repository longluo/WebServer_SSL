# Keil uVision project WebServer_SSL.uvproj, settings and files
target WebServer_SSL (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WebServer_SSL +hex
  c flags: Optim=1
  c define: rvmdk PART_LM3S8962 LUMINARY_MICRO
  c include: ..\..\Source\App\Head;..\..\Source\HAL\Evm\Head;..\..\Source\HAL\Oled\Head;..\..\Source\HAL\Io\Head;..\..\Source\LM3S_Lib;..\..\Source\LM3S_Lib\inc;..\..\Source\LM3S_Lib\DriverLib;..\..\Source\lwip-1.3.2\ports\stellaris\include;..\..\Source\lwip-1.3.2\src\include;..\..\Source\lwip-1.3.2\src\include\ipv4;..\..\Source\lwip-1.3.2\apps\httpserver_raw;..\..\Source\lwipConfig;..\..\Source\Utils\Head;..\..\Source\WebServer;..\..\Source\MatrixSSL;..\..\Source\SSL\Layer\Head;..\..\Source\fatfs\src;..\..\Source\MemManage;..\..\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/Src/: main.c
  group HAL
    ../../Source/HAL/Oled/Src/: rit128x96x4.c display.c
    ../../Source/HAL/: Startup_rvmdk.S
  group Lwip
    ../../Source/lwipConfig/: lwiplib.c
  group SSL-src
    ../../Source/MatrixSSL/src/: cipherSuite.c matrixSsl.c sslDecode.c sslEncode.c sslv3.c
  group SSL-src-cryto
    ../../Source/MatrixSSL/src/crypto/peersec/: arc4.c base64.c des3.c md2.c md5.c mpi.c rsa.c sha1.c
  group SSL-src-pki
    ../../Source/MatrixSSL/src/pki/: asn1.c rsaPki.c x509.c
  group SSL-src-os
    ../../Source/MatrixSSL/src/os/no_os/: no_os.c
    ../../Source/MatrixSSL/src/os/: debug.c
  group SSL-cert
    ../../Source/SSL/Cert/: privkeySrv.c certSrv.c
  group SSL-layer
    ../../Source/SSL/Layer/Src/: ssl.c
  group MemManage
    ../../Source/MemManage/: bget.c
  group FS
    ../../Source/fatfs/src/: ff.c
    ../../Source/fatfs/port/: mmc-ek-lm3s8962.c
  group WebServer
    ../../Source/WebServer/: httpsd.c lmi_fs.c
  group Utils
    ../../Source/Utils/Src/: uartstdio.c ustdlib.c
  group LM3S_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
